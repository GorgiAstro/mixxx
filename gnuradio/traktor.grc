options:
  parameters:
    generate_options: qt_gui
    id: lol
    output_language: python
    title: Bonjour
  states: {}

blocks:
- name: carrier_freq_approx
  id: variable
  parameters:
    value: '2500'
  states: {}
- name: fsk_deviation_hz
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: low_freq
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: pi
  id: variable
  parameters:
    value: '3.14159265358979323846'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '96000'
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: '1200'
  states: {}
- name: analog_agc2_xx_0
  id: analog_agc2_xx
  parameters:
    attack_rate: '1e-1'
    decay_rate: '1e-2'
    gain: '1.0'
    max_gain: '65536'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_pll_freqdet_cf_0
  id: analog_pll_freqdet_cf
  parameters:
    max_freq: (carrier_freq_approx+200)*2*pi/samp_rate
    min_freq: (carrier_freq_approx-200)*2*pi/samp_rate
    w: pi/500.0
  states: {state: disabled}
- name: blocks_complex_to_float_0_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_magphase_0
  id: blocks_complex_to_magphase
  parameters: {}
  states: {}
- name: blocks_complex_to_magphase_0_0
  id: blocks_complex_to_magphase
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/yzokras/mag_times_phase_decimated.bin
    type: float
  states: {state: disabled}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /home/yzokras/phasor.bin
    type: float
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: samp_rate/(2*pi)
    type: float
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /media/yzokras/ssd/git/mixxx/gnuradio/traktor_mk2_side_a.wav
    nchan: '2'
    repeat: 'False'
  states: {}
- name: digital_cma_equalizer_cc_0
  id: digital_cma_equalizer_cc
  parameters:
    modulus: '1'
    mu: '0.01'
    num_taps: '15'
    sps: '1'
  states: {state: disabled}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: '0.0628'
  states: {state: disabled}
- name: digital_diff_phasor_cc_0
  id: digital_diff_phasor_cc
  parameters: {}
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: '48'
    ted_gain: '1.0'
    ted_type: digital.TED_SIGNUM_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: symbol_rate
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '100'
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    size: '1000'
    type: complex
    update_time: '0.1'
    xmax: '0.5'
    xmin: '-0.5'
    ymax: '0.5'
    ymin: '-0.5'
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    size: '1000'
    type: complex
    update_time: '0.1'
    xmax: '0.5'
    xmin: '-0.5'
    ymax: '0.5'
    ymin: '-0.5'
  states: {state: disabled}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    name: mag_after_filter
    size: int(samp_rate*50/1000)
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    name: phase_after_filter
    size: int(samp_rate*50/1000)
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    name: phase_after_filter
    size: int(symbol_rate*50/1000)
    srate: symbol_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0_0_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    name: mag_after_decim
    size: int(symbol_rate*50/1000)
    srate: symbol_rate
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    type: complex
    update_time: '0.05'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0_0_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    type: complex
    update_time: '0.05'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '48'
    interp: '1'
    taps: ''
    type: fff
  states: {state: disabled}

connections:
- [analog_agc2_xx_0, '0', analog_pll_freqdet_cf_0, '0']
- [analog_agc2_xx_0, '0', low_pass_filter_0_0, '0']
- [analog_agc2_xx_0, '0', qtgui_waterfall_sink_x_0_0_0, '0']
- [analog_pll_freqdet_cf_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_complex_to_float_0_0, '0', blocks_file_sink_0_0, '0']
- [blocks_complex_to_magphase_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [blocks_complex_to_magphase_0, '1', qtgui_time_sink_x_0_0_0_0, '0']
- [blocks_complex_to_magphase_0_0, '0', qtgui_time_sink_x_0_0_0_1, '0']
- [blocks_complex_to_magphase_0_0, '1', qtgui_time_sink_x_0_0_0_0_0, '0']
- [blocks_float_to_complex_0, '0', analog_agc2_xx_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_number_sink_0, '0']
- [blocks_throttle_0, '0', blocks_float_to_complex_0, '1']
- [blocks_throttle_0_0, '0', blocks_float_to_complex_0, '0']
- [blocks_wavfile_source_0, '0', blocks_throttle_0, '0']
- [blocks_wavfile_source_0, '1', blocks_throttle_0_0, '0']
- [digital_cma_equalizer_cc_0, '0', digital_costas_loop_cc_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0_0, '0']
- [digital_diff_phasor_cc_0, '0', blocks_complex_to_float_0_0, '0']
- [digital_symbol_sync_xx_0, '0', blocks_complex_to_magphase_0_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_diff_phasor_cc_0, '0']
- [low_pass_filter_0_0, '0', blocks_complex_to_magphase_0, '0']
- [low_pass_filter_0_0, '0', digital_symbol_sync_xx_0, '0']
- [low_pass_filter_0_0, '0', qtgui_const_sink_x_0, '0']
- [low_pass_filter_0_0, '0', qtgui_waterfall_sink_x_0_0_0_0, '0']
- [rational_resampler_xxx_0, '0', blocks_file_sink_0, '0']

metadata:
  file_format: 1
